# Keil uVision project 111.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 111 +hex
  c flags: Optimize=8 SizeSpeed=1
  group ource Group 1
    ./: STARTUP.A51 AT89C51.c
